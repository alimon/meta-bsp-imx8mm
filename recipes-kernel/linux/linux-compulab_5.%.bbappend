require linux-compulab.inc

